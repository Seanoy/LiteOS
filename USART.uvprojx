# Keil uVision project USART.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,LOS_KERNEL_DEBUG_OUT
  c include: .\CMSIS;.\FWlib\inc;.\;.\user;.\BSP\inc;.\LiteOS\OS_CONFIG;.\LiteOS\arch\arm\arm-m\include;.\LiteOS\kernel\include;.\LiteOS\kernel\base\include;.\LiteOS\kernel\extended\include;.\LiteOS\arch\arm\common\cmsis;.\demo\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group user
    ./user/: main.c stm32f10x_it.c
    ./: USART.c
    ./demo/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_demo_entry.c los_inspect_entry.c
  group startup
    ./startup/: startup_stm32f10x_md.s
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ./BSP/src/: bsp.c bsp_sys.c bsp_systick.c bsp_led.c
  group LiteOS/arch
    ./LiteOS/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
    ./LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group LiteOS/kernal
    ./LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ./LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ./LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ./LiteOS/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ./LiteOS/kernel/base/mem/membox/: los_membox.c
    ./LiteOS/kernel/base/misc/: los_misc.c
    ./LiteOS/kernel/extended/tickless/: los_tickless.c
    ./LiteOS/kernel/: los_init.c
    ./LiteOS/kernel/base/om/: los_err.c
software components: CMSIS:CORE 5.0.1
